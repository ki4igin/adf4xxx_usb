# Keil uVision project adf4xxx_usb.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: adf4xxx_usb +hex
  c flags: Optimize=8
  group main
    ./src/: adf4xxx_usb.c fw.c
  group asm
    ./src/: dscr.a51 USBJmpTb.a51
  group lib
    ./src/: EZUSB.LIB
target fx2sdly.h (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0xE000-0xE3FF) CLOCK(48000000) MODDP2
  output: adf4xxx_usb
  c flags: Optimize=8 SizeSpeed=1
